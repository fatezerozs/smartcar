# Keil uVision project recorder_b2.uvprojx, settings and files
target RECORDER_CAMERA_B2_STATIC_1 (6210000::V6.21::ARMCLANG)
  device: MIMXRT1064DVL6B NXP
  pack: NXP.MIMXRT1064_DFP.26.09.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: recorder_b2
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RECORDER_TRAINING=1,VISION_MIDTERM_TRAINING=1,VISION_ENCODER_ENABLE=0,VISION_DRIVE_ENABLE=0,VISION_MIDTERM_AUTONOMOUS=0,VISION_MIDTERM_ROUTE_TRIAL=0,VISION_ROUTE_SWITCH=0,VISION_START_SWITCH_ENABLE=0,VISION_DUAL_UART_ENABLE=0,MIDTERM_VISUAL_REVIEWED=0,CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1,XIP_BOOT_HEADER_DCD_ENABLE=1,XIP_BOOT_HEADER_ENABLE=1,FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0,SDK_DEBUGCONSOLE=0,SD_ENABLED,DEBUG
  c misc: -fno-common -fdata-sections -ffunction-sections -ffreestanding -fno-builtin -mthumb -Wno-invalid-source-encoding -include "C:/shengchanli/smartCar/smartcar/demo/recorder_b2/include/b2_build.h"
  c include: C:\shengchanli\smartCar\smartcar\demo\recorder_b2\include;C:\shengchanli\smartCar\smartcar\demo\recorder\include;C:\shengchanli\smartCar\smartcar\.build\recorder-camera-stages-20261106\run-20261105T194348-27184-final\adapted;C:\shengchanli\smartCar\smartcar\libraries\third_party\FreeRTOS-Kernel\include;C:\shengchanli\smartCar\smartcar\libraries\third_party\FreeRTOS-Kernel\portable\GCC\ARM_CM7\r0p1;C:\shengchanli\smartCar\smartcar\demo\user\inc;C:\shengchanli\smartCar\smartcar\demo\code;C:\shengchanli\smartCar\smartcar\libraries\sdk\startup\mdk;C:\shengchanli\smartCar\smartcar\libraries\sdk\deceive;C:\shengchanli\smartCar\smartcar\libraries\sdk\drives;C:\shengchanli\smartCar\smartcar\libraries\sdk\xip;C:\shengchanli\smartCar\smartcar\libraries\sdk\utilities;C:\shengchanli\smartCar\smartcar\libraries\sdk\utilities\debug_console;C:\shengchanli\smartCar\smartcar\libraries\sdk\utilities\str;C:\shengchanli\smartCar\smartcar\libraries\sdk\cmsis_drivers;C:\shengchanli\smartCar\smartcar\libraries\sdk\CMSIS\Include;C:\shengchanli\smartCar\smartcar\libraries\sdk\CMSIS\Driver\Include;C:\shengchanli\smartCar\smartcar\libraries\sdk\components\lists;C:\shengchanli\smartCar\smartcar\libraries\sdk\components\osa;C:\shengchanli\smartCar\smartcar\libraries\sdk\components\serial_manager;C:\shengchanli\smartCar\smartcar\libraries\sdk\components\uart;C:\shengchanli\smartCar\smartcar\libraries\sdk\board;C:\shengchanli\smartCar\smartcar\libraries\components\fatfs\source;C:\shengchanli\smartCar\smartcar\libraries\components\fatfs\source\fsl_sd_disk;C:\shengchanli\smartCar\smartcar\libraries\components\sdmmc;C:\shengchanli\smartCar\smartcar\libraries\components\sdmmc\common;C:\shengchanli\smartCar\smartcar\libraries\components\sdmmc\host\usdhc;C:\shengchanli\smartCar\smartcar\libraries\components\sdmmc\osa;C:\shengchanli\smartCar\smartcar\libraries\components\sdmmc\sd;C:\shengchanli\smartCar\smartcar\libraries\components\usb\device;C:\shengchanli\smartCar\smartcar\libraries\components\usb\include;C:\shengchanli\smartCar\smartcar\libraries\components\usb\phy;C:\shengchanli\smartCar\smartcar\libraries\components\usb\usb_cdc_adapter;C:\shengchanli\smartCar\smartcar\libraries\zf_common;C:\shengchanli\smartCar\smartcar\libraries\zf_driver;C:\shengchanli\smartCar\smartcar\libraries\zf_device
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20280000 size 0x40000
  memory RVCT7: RAM 0x20200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: C:\shengchanli\smartCar\smartcar\demo\mdk\scf\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler
  group stationary_camera_no_actuators
    C:/shengchanli/smartCar/smartcar/libraries/sdk/startup/mdk/: startup_MIMXRT1064.S
    C:/shengchanli/smartCar/smartcar/libraries/sdk/deceive/: system_MIMXRT1064.c
    C:/shengchanli/smartCar/smartcar/libraries/sdk/board/: board.c clock_config.c
    C:/shengchanli/smartCar/smartcar/libraries/sdk/drives/: fsl_common.c fsl_common_arm.c fsl_clock.c fsl_gpio.c fsl_gpt.c fsl_csi.c fsl_dcdc.c fsl_lpuart.c fsl_cache.c
    C:/shengchanli/smartCar/smartcar/libraries/components/sdmmc/common/: fsl_sdmmc_common.c
    C:/shengchanli/smartCar/smartcar/libraries/zf_device/: zf_device_config.lib zf_device_camera.c zf_device_type.c
    C:/shengchanli/smartCar/smartcar/libraries/sdk/xip/: fsl_flexspi_nor_boot.c evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c
    C:/shengchanli/smartCar/smartcar/libraries/zf_common/: zf_common_clock.c zf_common_interrupt.c zf_common_function.c zf_common_fifo.c
    C:/shengchanli/smartCar/smartcar/libraries/zf_driver/: zf_driver_gpio.c zf_driver_uart.c zf_driver_delay.c zf_driver_timer.c zf_driver_soft_iic.c zf_driver_csi.c
    C:/shengchanli/smartCar/smartcar/libraries/third_party/FreeRTOS-Kernel/: tasks.c queue.c list.c
    C:/shengchanli/smartCar/smartcar/libraries/third_party/FreeRTOS-Kernel/portable/GCC/ARM_CM7/r0p1/: port.c
    C:/shengchanli/smartCar/smartcar/.build/recorder-camera-stages-20261106/run-20261105T194348-27184-final/adapted/: zf_device_mt9v03x.c fsl_sdmmc_host.c sdmmc_config.c fsl_sd.c fsl_usdhc.c ff.c diskio.c ffunicode.c
    C:/shengchanli/smartCar/smartcar/demo/recorder/: recorder_core.c recorder_capture.c recorder_storage.c recorder_disk.c recorder_sd_pins.c recorder_sd_osa.c
    C:/shengchanli/smartCar/smartcar/demo/recorder_b2/: b2_main.c
