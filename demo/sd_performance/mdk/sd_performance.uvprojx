# Keil uVision project sd_performance.uvprojx, settings and files
target SD_Performance (6210000::V6.21::ARMCLANG)
  device: MIMXRT1064DVL6B NXP
  pack: NXP.MIMXRT1064_DFP.26.09.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: sd_performance
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1,XIP_BOOT_HEADER_ENABLE=1,XIP_BOOT_HEADER_DCD_ENABLE=0,SD_ENABLED,DEBUG,DISABLE_WDOG=1,SDK_DEBUGCONSOLE=0
  c misc: -fno-common -ffunction-sections -fdata-sections -mthumb -Wno-invalid-source-encoding -include ../include/ffconf.h
  c include: ..\include;..\..\..\libraries\sdk\deceive;..\..\..\libraries\sdk\drives;..\..\..\libraries\sdk\CMSIS\Include;..\..\..\libraries\sdk\board;..\..\..\libraries\sdk\xip;..\..\..\libraries\sdk\components\osa;..\..\..\libraries\components\fatfs\source;..\..\..\libraries\components\sdmmc\osa;..\..\..\libraries\components\sdmmc\sd;..\..\..\libraries\components\sdmmc\common;..\..\..\libraries\components\sdmmc\host\usdhc;..\..\..\libraries\sdk\components\lists
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20280000 size 0x40000
  memory RVCT7: RAM 0x20200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: sd_performance.scf
  link misc: --remove --entry=Reset_Handler
  group SD_Diagnostic_only
    ../: board.c diag_core.c osa.c sd_policy.c host_policy.c diag_system.c bench.c export.c
    ../../../libraries/sdk/startup/mdk/: startup_MIMXRT1064.S
    ../../../libraries/sdk/drives/: fsl_common.c fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_usdhc.c fsl_cache.c
    ../../../libraries/sdk/xip/: evkmimxrt1064_flexspi_nor_config.c fsl_flexspi_nor_boot.c
    ../../../libraries/components/sdmmc/common/: fsl_sdmmc_common.c
    ../../../libraries/components/fatfs/source/: ff.c
